# KOMPAS-3D part (éæ-3(5)î-òò.m3d)

Model tree:
1. Объединить компоненты:1

Referenced files in D:\Работа\Мещеряков\Сигнализатор ВС\Черновики\: ВС-3(5)М-КЗ (.061, .062).a3d